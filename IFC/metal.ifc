Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:On], Option [Assemblies:On], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:On], Option [SurfaceTreatments:On], Option [LocationBy:0], Option [ViewColors:On], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: metal.ifc
Time: 2021-05-31T18:28:53
Author: DESKTOP-JK8PV89\luisa
Organization: Structural Designer
Written by: IFC Database Version: Work
Made in: Tekla Structures Educational 2020 Service Pack 3, IFC Export Version: 4.0.0.0 Sep 22 2020

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: IPE300, VIGA
In: Undefined
Description: IPE300; Material: STEEL/S275JR
Trimble Connect - MATERIAL: S275JR; PROFILE: IPE300; PART_POS: C0(?); ASSEMBLY_POS: C0(?)
Tekla Common - Bottom elevation: +5.701; Top elevation: +6.500; Phase: 1; Class: 3
Tekla Quantity - Weight: 254.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 27.5 m2; Net surface area: 7 m2; Height: 300 mm; Width: 150 mm; Length: 6020.8 mm
Pset_BeamCommon - LoadBearing: no; Reference: C0(?)
BaseQuantities - Length: 6020.8 mm; OuterSurfaceArea: 6.98412 m2; NetVolume: 0.0325077 m3; NetWeight: 255.185 kg

# IfcColumn: HEA240, PILAR
In: Undefined
Description: HEA240; Material: STEEL/S275JR
Trimble Connect - MATERIAL: S275JR; PROFILE: HEA240; PART_POS: C0(?); ASSEMBLY_POS: C0(?)
Tekla Common - Bottom elevation: +0.000; Top elevation: +6.000; Phase: 1; Class: 7
Tekla Quantity - Weight: 361.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 22.7 m2; Net surface area: 8.2 m2; Height: 230 mm; Width: 240 mm; Length: 6000 mm
Pset_ColumnCommon - LoadBearing: no; Reference: C0(?)
BaseQuantities - Length: 6000 mm; OuterSurfaceArea: 8.214 m2; NetVolume: 0.0463134 m3; NetWeight: 363.56 kg

# IfcElementAssembly (2)
In: Undefined
PredefinedType: RIGID_FRAME
Tekla Assembly - Assembly/Cast unit Mark: C0(?)
Name | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Assembly/Cast unit position code | Width (mm)
VIGA | 254.3 | +5.701 | +6.500 | 1/C-E | 150
PILAR | 361.7 | +0.000 | +6.000 | 1/E | 240
